# Keil uVision project Application_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x1400-0x3FFBF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Application_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h BLA.c BLA.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LDON_aliases.h LDON.c LDON.h LDON_CK.c LDON_CK.h HB_aliases.h HB.c HB.h LDON_CR.c LDON_CR.h MISO_aliases.h MISO.c MISO.h MOSI_aliases.h MOSI.c MOSI.h SCLK_aliases.h SCLK.c SCLK.h ETH.c ETH.h ETH_PM.c ETH_INT.c ETH_PVT.h ECS_aliases.h ECS.c ECS.h DMA_RX_dma.c DMA_RX_dma.h DMA_TX_dma.c DMA_TX_dma.h ETH_IntClock.c ETH_IntClock.h URT.c URT.h URT_PM.c URT_INT.c URT_BOOT.c URT_IntClock.c URT_IntClock.h ETW.c ETW.h EINT_aliases.h EINT.c EINT.h ETE.c ETE.h TEST_aliases.h TEST.c TEST.h EPM.c EPM.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Application_PSoC5lib (library)
